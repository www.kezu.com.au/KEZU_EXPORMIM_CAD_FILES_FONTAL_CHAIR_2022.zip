Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: 0001
Time: 2020-05-21T17:26:27
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190108_1515(x64) - Exporter 19.2.1.1 - IU alternativa 19.2.1.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu May 21 17:26:27 2020 * Host: DESKTOP-5OV4RIT * Database: C:\Users\34629\AppData\Local\Temp\{D96EBC79-1D83-4D55-85EB-6514C1B134D0}\ifc * Database version: 5507 * Database creation date: Thu May 21 17:26:26 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu May 21 17:26:27 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu May 21 17:26:27 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nombre de proyecto; Phase: Estado de proyecto

# IfcSite, Default
RefLatitude: 40, 25, 13, 9643; RefLongitude: -3, -42, -20, -772056; RefElevation: 0 mm
Otros - Categoría: Información de proyecto; Dirección de proyecto: Introduzca dirección aquí; Estado de proyecto: Estado de proyecto; Fecha de emisión de proyecto: Fecha de emisión; Nombre de cliente: Propietario; Nombre de proyecto: Nombre de proyecto; Número de proyecto: 0001

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Otros - Categoría: Información de proyecto; Dirección de proyecto: Introduzca dirección aquí; Estado de proyecto: Estado de proyecto; Fecha de emisión de proyecto: Fecha de emisión; Nombre de cliente: Propietario; Nombre de proyecto: Nombre de proyecto; Número de proyecto: 0001

# IfcBuildingStorey, Nivel 1
LongName: Nivel 1; Elevation: 0 mm
Restricciones(Type) - Altura base: Punto base del proyecto
Otros(Type) - Categoría: Niveles; Nombre de familia: Nivel
Gráficos(Type) - Color: 0; Grosor de línea: 1; Patrón de línea: Sólido; Símbolo: Extremo inicial de nivel - Círculo: Extremo inicial de nivel - Círculo; Símbolo en extremo 1 por defecto: no; Símbolo en extremo 2 por defecto: yes
Datos de identidad(Type) - Nombre de tipo: Extremo inicial 8 mm
Cotas - Altura de cálculo: 0 mm
Datos de identidad - Estructura: no; Nombre: Nivel 1; Planta de edificio: yes
Otros - Categoría: Niveles; Familia: Nivel: Extremo inicial 8 mm; Familia y tipo: Nivel: Extremo inicial 8 mm; ID de tipo: Nivel: Extremo inicial 8 mm; Tipo: Nivel: Extremo inicial 8 mm
Restricciones - Alzado: 0 mm

# IfcFurnishingElement: 0,58 x 0,56 x 0,82 m / 22.75" x 22" x 32.25", 2019_EN_Chair_Expormim_T011-U-Fontal:0,58 x 0,56 x 0,82 m / 22.75" x 22" x 32.25":141645
In: Nivel 1
Type - ElementType: 0,58 x 0,56 x 0,82 m / 22.75" x 22" x 32.25"; Material: Linen, Beige, Rubber, black, Rattan
Type - Cotas - Height: 820 mm; Length: 580 mm; SeatHeight: 490 mm; Weight: 7; Width: 560 mm
Type - Datos - System: Furniture
Type - Datos de identidad - Author: Bimetica Parametric Design Services SL; BIMEelementExpiryDate: 20/05/2021; BIMElementIssueDate: 20/05/2020; Bimetica: www.bimetica.com; BimeticaProductProfileURL: https://bimetica.com/es/bim-object-expormim-fontal-dining-chair-oscar-tusquets-blanca-4738.html; BIM Support: https://bimsupport.info/es/fabricantes/expormim-bim/; Comentarios de tipo: Unique and exclusive pieces created by world-renowned designers with an outstanding career and much experience. “This project is born from the wish to recover rattan as a fine material and reclaim our country’s rich craftsmanship tradition. I have tried to give a new look to an ancient technique replacing the brackets and bonds traditionally used as connecting elements by the twinning of one cane to the next. Thanks to this innovative solution we have achieved a strong, flexible and lightweight structure. This is how Fontal evolves into a warm, likeable and luxurious seat in the true sense of the word.”; CountryOfSale: AUSTRALIA, BELGIUM, CANADA, FRANCE, GERMANY, ISRAEL, ITALY, JAMAICA, JAPAN, JORDAN, KAZAKHSTAN, KENYA, KOREA, KOSOVO, KUWAIT, LATVIA, LEBANON, LIBYA, LITHUANIA, MACEDONIA, MALAYSIA, MALT, MOROCCO, MAURITIUS, MEXICO, MIDDLE EAST, NICARAGUA, NORWAY, NEW ZEALAND, PANAMA, PERU, POLAND, PORTUGAL, PUERTO RICO, QUATAR, UNITED KINGDOM, USA, REP.OF MALDIVES, REPUBLIC OF YEMEN, CZECH REPUBLIC, REPUBLIC OF SAN MARINO, DOMINICAN REPUBLIC, ROMANIA, RUSSIA, SENEGAL, SERBIA, SINGAPORE, SOUTH AFRICA, SPAIN, SRI LANKA, SWEDEN, SWITZERLAND, SULTANATE OF OMAN, THAILAND, TAIWAN, TUNISIA, TURKEY, UKRAINE, UNITED ARAB EMIRATES, URUGUAY, VENEZUELA, VIETNAM, VIRGIN ISLANDS,; Descripción: Upholstered dining armchair; Designer: Oscar Tusquets Blanca; Fabricante: EXPORMIM S.A.; IsExternal: no; LicenseNumber: XXX-XXXX4564; Modelo: T011 U upholstered dining armchair; Nombre de tipo: 0,58 x 0,56 x 0,82 m / 22.75" x 22" x 32.25"; Número OmniClass: 23.40.20.00; Owner: EXPORMIM S.A.; ProductionYear: 2012; ProductURL: https://www.expormim.com/product_collections/indoor/product_familys/fontal/; SalesRepresentativeContact: export@expormim.com; Series: Fontal; TechnicalInformation: https://downloads.expormim.com/direct/VqzDkg6Llp/folder/762; TechnicalSupportContact: expormim@bimsupport.info; TelephoneContact: 0034 962 295 144; Título OmniClass: General Furniture and Specialties; URL: https://www.expormim.com; Version: RVT-2019
Type - Materiales y acabados - Collection: indoor; Finish: Upholstered dining armchair with structure made of peeled and tinted natural rattan 32 mm/1.26” diameter. Finished with a three step coating (dye, base coat and top coat) highly resistant to solar radiation thanks to UV filters. Seat upholstery in natural or faux leather, virgin wool fabrics, velvet and polypropylene. Protective caps with removable plastic-felt inserts.; HousingMaterial: Rattan; PrimaryColor: explore expormim indoor catalogue
Type - Otros - Categoría: Mobiliario; Nombre de familia: 2019_EN_Chair_Expormim_T011-U-Fontal
Pset_ManufacturerTypeInformation - Manufacturer: EXPORMIM S.A.; ProductionYear: 2012
Cantidades de mobiliario - Descripción de unidad: 2019_EN_Chair_Expormim_T011-U-Fontal: 0,58 x 0,56 x 0,82 m / 22.75" x 22" x 32.25"; Tipo: 2019_EN_Chair_Expormim_T011-U-Fontal: 0,58 x 0,56 x 0,82 m / 22.75" x 22" x 32.25"; Descripción: Upholstered dining armchair; Fabricante: EXPORMIM S.A.; Modelo: T011 U upholstered dining armchair; URL: https://www.expormim.com; Comentarios: Unique and exclusive pieces created by world-renowned designers with an outstanding career and much experience. “This project is born from the wish to recover rattan as a fine material and reclaim our country’s rich craftsmanship tradition. I have tried to give a new look to an ancient technique replacing the brackets and bonds traditionally used as connecting elements by the twinning of one cane to the next. Thanks to this innovative solution we have achieved a strong, flexible and lightweight structure. This is how Fontal evolves into a warm, likeable and luxurious seat in the true sense of the word.”
Cotas - Área: 0.552973 m2; Volumen: 0.0128061 m3
Otros - Familia: 2019_EN_Chair_Expormim_T011-U-Fontal: 0,58 x 0,56 x 0,82 m / 22.75" x 22" x 32.25"; Familia y tipo: 2019_EN_Chair_Expormim_T011-U-Fontal: 0,58 x 0,56 x 0,82 m / 22.75" x 22" x 32.25"; ID de tipo: 2019_EN_Chair_Expormim_T011-U-Fontal: 0,58 x 0,56 x 0,82 m / 22.75" x 22" x 32.25"; Tipo: 2019_EN_Chair_Expormim_T011-U-Fontal: 0,58 x 0,56 x 0,82 m / 22.75" x 22" x 32.25"
Proceso por fases - Fase de creación: Fase 1
Restricciones - Anfitrión: Nivel : Nivel 1; Desfase: 0 mm; Nivel: Nivel: Nivel 1; Se mueve con elementos cercanos: no
